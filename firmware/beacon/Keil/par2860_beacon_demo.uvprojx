# Keil uVision project par2860_beacon_demo.uvprojx, settings and files
target Exmaple (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: par2860_beacon_demo +hex
  AfterMake: "Output\HEX2BIN.EXE" ".\Output\par2860_beacon_demo.hex"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Keil;..\Include;..\..\..\SDK\include;..\..\..\Lib;..\..\..\Setting\GattProfile;..\..\..\SDK\ota
  memory RVCT4: ROM 0x10000000 size 0x3f000
  memory RVCT9: RAM 0x20003000 size 0x5000
  group Main
    ../: main.c ble.c
    ../Include/: Beacon_Profile.h
  group Driver
    ../../../SDK/driver/: delay.c gpio.c debug.c timer.c gpadc.c uart.c wdt.c
  group Lib
    ../../../Lib/: pxi_2860_lib.lib
  group BEACON
    ../: beacon.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.1
